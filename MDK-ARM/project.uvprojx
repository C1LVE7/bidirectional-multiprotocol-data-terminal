# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ThirdParty/coreMQTT/include;../ThirdParty/coreMQTT/include/private;../ThirdParty/FreeRTOS/include;../ThirdParty/FreeRTOS/portable/RVDS/ARM_CM4F;../BSP;../APP;../Protocols
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ThirdParty\FreeRTOS\portable
    ../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../ThirdParty/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group ThirdParty\coreMQTT\src
    ../ThirdParty/coreMQTT/src/: core_mqtt.c core_mqtt_prop_deserializer.c core_mqtt_prop_serializer.c core_mqtt_serializer.c core_mqtt_serializer_private.c core_mqtt_state.c
    ../ThirdParty/coreMQTT/include/: core_mqtt_config.h
  group ThirdParty\FreeRTOS\source
    ../ThirdParty/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group BSP
    ../BSP/: bsp_uart.c bsp_uart.h bsp_led.c bsp_led.h bsp_sensor.c bsp_sensor.h bsp_wifi.c bsp_wifi.h
  group APP
    ../APP/: app_config.h app_tasks.c app_tasks.h app_hooks.c
  group Protocols
    ../Protocols/: mqtt_client.h mqtt_client.c modbus_rtu_master.c modbus_rtu_master.h
software components: CMSIS:CORE 4.3.0
